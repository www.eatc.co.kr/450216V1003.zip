# Autodesk Inventor part: 키5x5
## iProperties
Created: 2013-08
Part Number: 키5x5
Document SubType Name: Modeling
Designer: 한국산업디자인학원
Density: 1 g/cm^3
Author: 한국산업디자인학원
