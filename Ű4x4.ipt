# Autodesk Inventor part: 키4x4
## iProperties
Created: 2013-08
Part Number: 키4x4
Document SubType Name: Modeling
Designer: 한국산업디자인학원
Density: 1 g/cm^3
Author: 한국산업디자인학원
