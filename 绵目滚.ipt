# Autodesk Inventor part: 축 커버
## iProperties
Created: 2013-08
Part Number: 축 커버
Document SubType Name: Modeling
Designer: 한국산업디자인학원
Density: 1 g/cm^3
Author: 한국산업디자인학원
